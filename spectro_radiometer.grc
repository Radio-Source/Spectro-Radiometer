options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: spectro_radiometer
    output_language: python
    title: Spectral and Radiometry Receiver
  states: {}

blocks:
- name: actual_dec_label
  id: variable_qtgui_label
  parameters:
    gui_hint: main_tab@0:1,1,1,1
    label: Actual DEC
    type: real
    value: spectro_helper.get_decln(ui_decln,decfile,tp_pacer)
  states: {}
- name: ang
  id: variable_qtgui_range
  parameters:
    gui_hint: main_tab@1:1,0,1,3
    label: Phase Angle Adjust
    start: '-180'
    step: '2'
    stop: '180'
    value: '0'
    widget: slider
  states: {}
- name: anno_status
  id: variable
  parameters:
    value: spectro_helper.do_annotation(ira,declination,baseline,annotation,srate*0.8,abw,ifreq,srate,prefix)
  states: {}
- name: annotation
  id: variable_qtgui_entry
  parameters:
    gui_hint: main_tab@0:2,1,1,2
    label: Quick Annotation
    type: string
    value: '""'
  states: {}
- name: baseline_clear_status
  id: variable
  parameters:
    value: spectro_helper.baseline_clearer(clear_baseline)
  states: {}
- name: baseline_set_status
  id: variable
  parameters:
    value: spectro_helper.baseline_setter(set_baseline)
  states: {}
- name: clear_baseline
  id: variable_qtgui_push_button
  parameters:
    gui_hint: main_tab@0:0,1,1,1
    label: Clear Baseline
    pressed: '1'
    released: '0'
    type: int
    value: '0'
  states: {}
- name: clk_deriv
  id: variable
  parameters:
    value: '''None if clock in ["none", "default"] else clock'''
  states: {}
- name: corr_probed
  id: variable_function_probe
  parameters:
    block_id: corr_probe
    function_name: level
    poll_rate: fft_hz
    value: complex(0.0,0.0)
  states: {}
- name: curr_dx
  id: variable
  parameters:
    value: spectro_helper.curr_diff(fft_probed,enable_normalize,fftsize,0)
  states: {}
- name: curr_dx2
  id: variable
  parameters:
    value: spectro_helper.curr_diff(fft_probed,enable_normalize,fftsize,1)
  states: {}
- name: curr_tp_vect
  id: variable
  parameters:
    value: spectro_helper.get_tp_vect(tp_pacer)
  states: {}
- name: custom_window
  id: variable
  parameters:
    value: sinc*np.hamming(nphase*nchan)
  states: {}
- name: dcblock
  id: variable_qtgui_check_box
  parameters:
    'false': '0'
    gui_hint: main_tab@1:2,0,1,1
    label: Enable DC block
    'true': '1'
    type: int
    value: 'True'
  states: {}
- name: dcgain
  id: variable_qtgui_chooser
  parameters:
    gui_hint: main_tab@1:0,2,1,1
    label: Detector Gain
    label0: 1e2
    label1: 1e3
    label2: 1e4
    label3: 1e5
    label4: 1e6
    num_opts: '5'
    option0: '100'
    option1: '1000'
    option2: '10000'
    option3: '100000'
    option4: '1000000'
    orient: Qt.QHBoxLayout
    type: int
    value: dcg
    widget: radio_buttons
  states: {}
- name: declination
  id: variable
  parameters:
    value: spectro_helper.get_decln(ui_decln,decfile,tp_pacer)
  states: {}
- name: ebw
  id: variable
  parameters:
    value: (samp_rate*0.8)/1.0e6
  states: {}
- name: enable_normalize
  id: variable
  parameters:
    value: '0'
  states: {}
- name: fft2_probed
  id: variable_function_probe
  parameters:
    block_id: fft2_probe
    function_name: level
    poll_rate: fft_hz
    value: '[-100.0]*fftsize'
  states: {}
- name: fft_avg
  id: variable_qtgui_range
  parameters:
    gui_hint: main_tab@0:1,2,1,1
    label: Int. Time (Sec.)
    start: '0.5'
    step: '0.5'
    stop: '300'
    value: integration
    widget: counter
  states: {}
- name: fft_hz
  id: variable
  parameters:
    value: '15'
  states: {}
- name: fft_log_status
  id: variable
  parameters:
    value: spectro_helper.fft_log(fft_probed,fft2_probed,corr_probed,ifreq,samp_rate,longitude,enable_normalize,prefix,declination,rfilist,dcgain,fft_avg,mode,zerotime,decfile,tp_interval,spec_interval,fft_hz)
  states: {}
- name: fft_probed
  id: variable_function_probe
  parameters:
    block_id: fft_probe
    function_name: level
    poll_rate: fft_hz
    value: '[-100.0]*fftsize'
  states: {}
- name: fftrate
  id: variable
  parameters:
    value: float(samp_rate/fftsize)
  states: {}
- name: fincr
  id: variable
  parameters:
    value: (samp_rate/1.0e6)/fftsize
  states: {}
- name: frate
  id: variable
  parameters:
    comment: Fringe rate
    value: (baseline/wlam)*7.3e-5*math.cos(math.radians(ui_decln))
  states: {}
- name: fringe_label
  id: variable_qtgui_label
  parameters:
    gui_hint: main_tab@1:0,1,1,1
    label: Fringe Period(secs)
    type: real
    value: 1.0/frate
  states: {}
- name: frotate
  id: variable
  parameters:
    value: spectro_helper.fringe_stop (tp_pacer, ra, decln, longitude, latitude, baseline, fstop, ang, ifreq)
  states: {}
- name: fstop
  id: variable_qtgui_check_box
  parameters:
    'false': 'False'
    gui_hint: main_tab@1:2,1,1,1
    label: Fringe Stop
    'true': 'True'
    type: int
    value: 'False'
  states: {}
- name: gmdate
  id: variable
  parameters:
    value: '"%04d%02d%02d" % (ltp.tm_year, ltp.tm_mon, ltp.tm_mday)'
  states: {}
- name: ifreq
  id: variable_qtgui_entry
  parameters:
    gui_hint: main_tab@0:0,2,1,1
    label: Frequency
    type: real
    value: frequency
  states: {}
- name: igain
  id: variable_qtgui_entry
  parameters:
    gui_hint: main_tab@0:0,3,1,1
    label: RF Gain
    type: real
    value: gain
  states: {}
- name: ira
  id: variable_qtgui_entry
  parameters:
    gui_hint: main_tab@0:2,0,1,1
    label: Target Right Ascension
    type: real
    value: ra
  states: {}
- name: km_incr
  id: variable
  parameters:
    value: (((samp_rate/fftsize)/ifreq)*299792)*-1.0
  states: {}
- name: ltp
  id: variable
  parameters:
    value: time.gmtime(time.time())
  states: {}
- name: mode_map
  id: variable
  parameters:
    value: '{"total" : "Continuum Power", "tp" : "Continuum Power", "diff" : "Differential/Added Power", "differential" : "Differential/Added Power", "correlator" : "Cross  Power", "interferometer": "Cross Power", "corr" : "Cross Power"}'
  states: {}
- name: nchan
  id: variable
  parameters:
    value: fftsize
  states: {}
- name: nphase
  id: variable
  parameters:
    value: '2'
  states: {}
- name: pchanwidth
  id: variable
  parameters:
    value: samp_rate/fbsize
  states: {}
- name: pparam
  id: variable
  parameters:
    value: prefix+"-"+gmdate+"-psr.params" if psrmode != 0 else "/dev/null"
  states: {}
- name: pparamstr
  id: variable
  parameters:
    value: '"%.2f,%.2f,%.4f,%.4f,%.4f,%d\n" % (psrate/1e3, pchanwidth/1e3, ifreq/1.0e6,samp_rate/1.0e6,ebw,fbsize)'
  states: {}
- name: psrate
  id: variable
  parameters:
    value: samp_rate/fftsize
  states: {}
- name: psrfilename
  id: variable
  parameters:
    value: prefix+"-"+gmdate+"-psr.rfb8" if psrmode != 0 else "/dev/null"
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: int(srate)
  states: {}
- name: save_filter
  id: variable
  parameters:
    value: open("poopy.dat", "w").write(str(list(custom_window)))
  states: {}
- name: secondary_lmst_label
  id: variable_qtgui_label
  parameters:
    gui_hint: main_tab@1:0,0,1,1
    label: LMST
    type: string
    value: spectro_helper.lmst_string(time_pacer,longitude)
  states: {}
- name: set_baseline
  id: variable_qtgui_push_button
  parameters:
    gui_hint: main_tab@0:0,0,1,1
    label: Set Baseline
    pressed: '1'
    released: '0'
    type: int
    value: '0'
  states: {}
- name: sinc
  id: variable
  parameters:
    value: np.sinc(sinc_sample_locations/np.pi)
  states: {}
- name: sinc_sample_locations
  id: variable
  parameters:
    value: np.arange(-np.pi*4/2.0, np.pi*4/2.0, (np.pi/nchan)*(4/nphase))
  states: {}
- name: spec_labels
  id: variable
  parameters:
    value: spectro_helper.get_spec_labels(mode)
  states: {}
- name: start_km
  id: variable
  parameters:
    value: spectro_helper.doppler_start(ifreq,dfreq,samp_rate)
  states: {}
- name: time_pacer
  id: variable_function_probe
  parameters:
    block_id: fft_probe
    function_name: level
    poll_rate: '2'
    value: '[-100.0]*fftsize'
  states: {}
- name: tp_pacer
  id: variable_function_probe
  parameters:
    block_id: fft_probe
    function_name: level
    poll_rate: '1'
    value: '[-100.0]*fftsize'
  states: {}
- name: ui_decln
  id: variable_qtgui_entry
  parameters:
    gui_hint: main_tab@0:1,0,1,1
    label: Declination
    type: real
    value: decln
  states: {}
- name: variable_qtgui_label_0
  id: variable_qtgui_label
  parameters:
    gui_hint: main_tab@0:1,3,1,1
    label: Local Mean Sidereal Time
    type: string
    value: spectro_helper.lmst_string(time_pacer,longitude)
  states: {}
- name: wchan
  id: variable_qtgui_chooser
  parameters:
    gui_hint: main_tab@0:2,3,1,1
    label: Waterfall Chan
    label0: '0'
    label1: '1'
    num_opts: '2'
    option0: '0'
    option1: '1'
    orient: Qt.QHBoxLayout
    type: int
    value: '0'
  states: {}
- name: win
  id: variable
  parameters:
    value: fft.window.blackmanharris(fftsize)
  states: {}
- name: winsum
  id: variable
  parameters:
    value: sum(map(lambda x:x*x, win))
  states: {}
- name: wlam
  id: variable
  parameters:
    comment: Wavelength in meters
    value: 299792000.0/ifreq
  states: {}
- name: wrstatus
  id: variable
  parameters:
    value: open(pparam, "w").write(pparamstr)
  states: {}
- name: abw
  id: parameter
  parameters:
    label: Analog  bandwidth
    type: eng_float
    value: 4.0e6
  states: {}
- name: antenna
  id: parameter
  parameters:
    label: Antenna
    type: str
    value: RX2
  states: {}
- name: baseline
  id: parameter
  parameters:
    label: Baseline length
    type: eng_float
    value: '20'
  states: {}
- name: bbgain
  id: parameter
  parameters:
    label: Baseband Gain
    type: eng_float
    value: '5'
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: curr_dx
    type: float
    vlen: fftsize
  states: {}
- name: blocks_add_const_vxx_0_0
  id: blocks_add_const_vxx
  parameters:
    const: curr_tp_vect[0]
    type: float
    vlen: '3600'
  states: {}
- name: blocks_add_const_vxx_0_0_0
  id: blocks_add_const_vxx
  parameters:
    const: curr_tp_vect[1]
    type: float
    vlen: '3600'
  states: {}
- name: blocks_add_const_vxx_0_1
  id: blocks_add_const_vxx
  parameters:
    const: curr_dx2
    type: float
    vlen: fftsize
  states: {}
- name: blocks_add_const_vxx_1
  id: blocks_add_const_vxx
  parameters:
    comment: |-
      Add a teensy weensy value here
      To keep from SIGFPE
      When stream is all 0s.
    const: '1.0e-14'
    type: complex
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_add_xx_1
  id: blocks_add_xx
  parameters:
    type: complex
    vlen: fftsize
  states: {}
- name: blocks_add_xx_1_0
  id: blocks_add_xx
  parameters:
    type: complex
    vlen: fftsize
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: fftsize
  states: {}
- name: blocks_complex_to_mag_squared_0_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: fftsize
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: '1'
    type: complex
    vlen: fftsize
  states: {}
- name: blocks_delay_0_1
  id: blocks_delay
  parameters:
    delay: '1'
    type: complex
    vlen: fftsize
  states: {}
- name: blocks_keep_m_in_n_0
  id: blocks_keep_m_in_n
  parameters:
    m: 2*fftsize
    n: 3*fftsize
    offset: '0'
    type: complex
  states: {}
- name: blocks_keep_m_in_n_0_0
  id: blocks_keep_m_in_n
  parameters:
    m: 2*fftsize
    n: 3*fftsize
    offset: '0'
    type: complex
  states: {}
- name: blocks_keep_one_in_n_0
  id: blocks_keep_one_in_n
  parameters:
    n: int((samp_rate/fftsize)/50)
    type: float
    vlen: fftsize
  states: {}
- name: blocks_keep_one_in_n_0_0
  id: blocks_keep_one_in_n
  parameters:
    n: int((samp_rate/fftsize)/50)
    type: float
    vlen: fftsize
  states: {}
- name: blocks_keep_one_in_n_1
  id: blocks_keep_one_in_n
  parameters:
    n: int(samp_rate/fft_hz)
    type: complex
  states: {}
- name: blocks_multiply_conjugate_cc_0
  id: blocks_multiply_conjugate_cc
  parameters:
    comment: |-
      The basic correlation operation
      Conjugate multiply of the two streams
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    comment: Allow for phase-adjust on one side
    const: frotate
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: '[0.0]*fftsize'
    type: float
    vlen: fftsize
  states: {}
- name: blocks_multiply_const_vxx_2
  id: blocks_multiply_const_vxx
  parameters:
    comment: When != 0, this turns on DC blocking
    const: dcblock
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_3
  id: blocks_multiply_const_vxx
  parameters:
    const: 1.0 if wchan == 0 else 0
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_3_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 1.0  if wchan == 1 else 0.0
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_4
  id: blocks_multiply_const_vxx
  parameters:
    const: custom_window[0:nchan]
    type: complex
    vlen: fftsize
  states: {}
- name: blocks_multiply_const_vxx_4_0
  id: blocks_multiply_const_vxx
  parameters:
    const: custom_window[-nchan:]
    type: complex
    vlen: fftsize
  states: {}
- name: blocks_multiply_const_vxx_4_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: custom_window[-nchan:]
    type: complex
    vlen: fftsize
  states: {}
- name: blocks_multiply_const_vxx_4_2
  id: blocks_multiply_const_vxx
  parameters:
    const: custom_window[0:nchan]
    type: complex
    vlen: fftsize
  states: {}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    k: '-20*math.log10(fftsize)-10.0*math.log10(winsum/fftsize)-20*math.log10(1)'
    n: '10'
    vlen: fftsize
  states: {}
- name: blocks_nlog10_ff_0_0
  id: blocks_nlog10_ff
  parameters:
    k: '-20*math.log10(fftsize)-10.0*math.log10(winsum/fftsize)-20*math.log10(1)'
    n: '10'
    vlen: fftsize
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: float
    vlen: '3600'
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: fftsize
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: fftsize
    type: complex
  states: {}
- name: blocks_sub_xx_0
  id: blocks_sub_xx
  parameters:
    type: complex
  states: {}
- name: clock
  id: parameter
  parameters:
    label: Clock Source
    type: str
    value: default
  states: {}
- name: corr_probe
  id: blocks_probe_signal_x
  parameters:
    type: complex
  states: {}
- name: cronk
  id: virtual_sink
  parameters:
    stream_id: pfb1
  states: {}
- name: dcg
  id: parameter
  parameters:
    label: Detector DC Gain
    type: intx
    value: '100'
  states: {}
- name: decfile
  id: parameter
  parameters:
    label: Declination File Name
    value: '""'
  states: {}
- name: decln
  id: parameter
  parameters:
    label: Observing Declination
    type: eng_float
    value: '0'
  states: {}
- name: device
  id: parameter
  parameters:
    label: SDR Device Name
    value: '"rtl=0 file=/dev/zero,rate=2.50e6"'
  states: {}
- name: dfreq
  id: parameter
  parameters:
    label: Alternet Doppler Cente Frequency
    type: eng_float
    value: '0.0'
  states: {}
- name: fbsize
  id: parameter
  parameters:
    label: PSR Filterbank size
    type: intx
    value: '128'
  states: {}
- name: fft2_probe
  id: blocks_probe_signal_vx
  parameters:
    type: float
    vlen: fftsize
  states: {}
- name: fft_probe
  id: blocks_probe_signal_vx
  parameters:
    type: float
    vlen: fftsize
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: fftsize
    forward: 'True'
    shift: 'True'
    type: complex
    window: '[]'
  states: {}
- name: fft_vxx_0_0
  id: fft_vxx
  parameters:
    fft_size: fftsize
    forward: 'True'
    shift: 'True'
    type: complex
    window: '[]'
  states: {}
- name: fftsize
  id: parameter
  parameters:
    label: FFT size
    type: intx
    value: '2048'
  states: {}
- name: frequency
  id: parameter
  parameters:
    label: Center Frequency
    type: eng_float
    value: 1420.4058e6
  states: {}
- name: gain
  id: parameter
  parameters:
    label: RF Gain
    type: eng_float
    value: '30'
  states: {}
- name: ifgain
  id: parameter
  parameters:
    label: IF Gain
    type: eng_float
    value: '5'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: from gnuradio import fft
  states: {}
- name: import_0_0_0
  id: import
  parameters:
    imports: import time
  states: {}
- name: import_0_1
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: integration
  id: parameter
  parameters:
    label: Integration Time (Sec.)
    type: eng_float
    value: '0.5'
  states: {}
- name: latitude
  id: parameter
  parameters:
    label: Local Latitude
    type: eng_float
    value: '44.9'
  states: {}
- name: longitude
  id: parameter
  parameters:
    label: Local Longitude
    type: eng_float
    value: '-76.03'
  states: {}
- name: main_tab
  id: qtgui_tab_widget
  parameters:
    label0: Spectral
    label1: Continuum
    num_tabs: '2'
  states: {}
- name: mode
  id: parameter
  parameters:
    label: Operation Mode
    value: '"total"'
  states: {}
- name: note_0
  id: note
  parameters:
    comment: |-
      We synthesize a strip chart by updating
      a vector from a function probe
      That vector contains the current strip-chart
      values.
    note: Such stripchart...
  states: {}
- name: note_1
  id: note
  parameters:
    note: Just a pacing source
  states: {}
- name: note_2
  id: note
  parameters:
    comment: Implement simple DC-block, very cheaply.
  states: {}
- name: note_3
  id: note
  parameters:
    comment: |-
      ******* GUI ZONE ******
      GUI CONTROL OBJECTS GO HERE!!
  states: {}
- name: note_4
  id: note
  parameters:
    comment: |-
      **** PARAMETER ZONE *****
      COMMAND-LINE PARAMS GO HERE!!
  states: {}
- name: note_5
  id: note
  parameters:
    comment: |-
      The two main FFT pathways
      Connected to the input filters
  states: {}
- name: note_6
  id: note
  parameters:
    comment: |-
      Compute a bunch of parameters to
      write to a parameters file for psrmode != 0
  states: {}
- name: note_7
  id: note
  parameters:
    comment: |-
      None of this pulsar stuff is
      fully fleshed out yet
      Probably fold in code from
      pulsar_filterbank when I'm 
      happy with it.
  states: {}
- name: note_8
  id: note
  parameters:
    comment: |-
      Credit for these variable initializations
        goes to the WVURAIL lab#5 on PFB
        spectrometer implementations
      (https://github.com/WVURAIL/dspira/tree/master/labs)
  states: {}
- name: note_9
  id: note
  parameters:
    comment: |-
      Original code from https://github.com/ccera-astro/spectro_radiometer
      Adapted in Ubuntu 24.04
      for Gnuradio 3.10.9.2  - Python3.12.3 - Qt 5.15.13
    note: Version
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    ant0: antenna
    ant1: antenna
    args: device
    bb_gain0: bbgain
    bb_gain1: bbgain
    bw0: abw
    bw1: abw
    corr1: '0'
    dc_offset_mode0: '2'
    dc_offset_mode1: '2'
    freq0: ifreq
    freq1: ifreq
    gain0: igain
    gain1: 'igain '
    gain_mode0: 'False'
    gain_mode1: 'False'
    if_gain0: ifgain
    if_gain1: ifgain
    iq_balance_mode1: '0'
    nchan: '2'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: ppstime
  id: parameter
  parameters:
    label: Time Source
    type: str
    value: internal
  states: {}
- name: prefix
  id: parameter
  parameters:
    label: Data File Prefix
    value: '"h1"'
  states: {}
- name: psrmode
  id: parameter
  parameters:
    label: Enable PSR mode
    type: intx
    value: '0'
  states: {}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    autoscale: 'True'
    grid: 'True'
    gui_hint: spec_tab@0
    label1: spec_labels[0]
    label2: spec_labels[1]
    name: '"Doppler Velocity"'
    nconnections: '2'
    showports: 'True'
    update_time: 1.0/15
    vlen: fftsize
    x_axis_label: '"Doppler Velocity (km/s)"'
    x_start: start_km
    x_step: km_incr
    x_units: '"km/s"'
    y_axis_label: '"Rel. Power (dB)"'
    y_units: '"dB"'
    ymax: '+5'
    ymin: '-1'
  states: {}
- name: qtgui_vector_sink_f_0_0
  id: qtgui_vector_sink_f
  parameters:
    grid: 'True'
    gui_hint: main_tab@1:3,0,2,4
    label1: spectro_helper.plotlabel(mode,0)
    label2: spectro_helper.plotlabel(mode,1)
    name: mode_map[mode]
    nconnections: '2'
    showports: 'True'
    update_time: 1.0/5.0
    vlen: '3600'
    x_axis_label: '"Time (Minutes)"'
    x_start: '0'
    x_step: '-(1.0/60.0)'
    x_units: '"Mins"'
    y_axis_label: '"Deteced Power (arb units)"'
    ymax: '1.5'
    ymin: '0.0'
  states: {}
- name: qtgui_vector_sink_f_0_1
  id: qtgui_vector_sink_f
  parameters:
    autoscale: 'True'
    grid: 'True'
    gui_hint: spec_tab@1
    label1: spec_labels[0]
    label2: spec_labels[1]
    name: '"Frequency (MHz)"'
    nconnections: '2'
    showports: 'True'
    update_time: 1.0/15
    vlen: fftsize
    x_axis_label: '"Frequency (MHz)"'
    x_start: (ifreq-samp_rate/2)/1.0e6
    x_step: fincr
    x_units: '"MHz"'
    y_axis_label: '"Rel. Power (dB)"'
    y_units: '"dB"'
    ymax: '+5'
    ymin: '-1'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    color1: '3'
    fc: ifreq
    fftsize: '1024'
    gui_hint: spec_tab@2
    int_max: '-40'
    int_min: '-90'
    name: Spectrogram
    showports: 'True'
    type: complex
    update_time: '0.2'
  states: {}
- name: ra
  id: parameter
  parameters:
    label: Target RA
    type: eng_float
    value: '12.0'
  states: {}
- name: rfilist
  id: parameter
  parameters:
    label: RFI Frequency List
    value: '""'
  states: {}
- name: single_pole_iir_filter_xx_0
  id: single_pole_iir_filter_xx
  parameters:
    alpha: spectro_helper.getalpha(fft_hz/2.0,fftrate)
    type: float
    vlen: fftsize
  states: {}
- name: single_pole_iir_filter_xx_0_0
  id: single_pole_iir_filter_xx
  parameters:
    alpha: spectro_helper.getalpha(fft_hz/2.0,fftrate)
    type: float
    vlen: fftsize
  states: {}
- name: single_pole_iir_filter_xx_1
  id: single_pole_iir_filter_xx
  parameters:
    alpha: spectro_helper.getalpha(fft_hz/2.0,samp_rate)
    type: complex
  states: {}
- name: single_pole_iir_filter_xx_2
  id: single_pole_iir_filter_xx
  parameters:
    alpha: spectro_helper.getalpha(frate/2.0,fft_hz)
    type: complex
  states: {}
- name: spec_interval
  id: parameter
  parameters:
    label: Spectral Logging Interval
    type: intx
    value: '15'
  states: {}
- name: spec_tab
  id: qtgui_tab_widget
  parameters:
    gui_hint: main_tab@0:3,0,1,4
    label0: Doppler
    label1: Frequency
    label2: Waterfall
    num_tabs: '3'
  states: {}
- name: spectro_helper
  id: epy_module
  parameters:
    comment: |-
      IMPORTED MODULE
      A bunch of helper bits and pieces for logging, etc
    source_code: "# this module will be imported in the into your flowgraph\nimport sys\nimport os\nimport time\nimport ephem\nimport operator\nimport math\nimport numpy\n\ndef getalpha(corner, srate):\n\tq = math.pow(math.e,-2.0*(corner/srate))\n\talpha = 1.0 - q\n\treturn alpha\n\n\nzeromap = {}\n\nlastt = time.time()\nlasttpt = time.time()\nfft_buffer = [1.0e-25]*2048\nfft2_buffer = [0.0]*2048\nbaseline_buffer=[0.0]*2048\nbaseline_buffer2=[0.0]*2048\nfreq_mask=[1.0]*2048\nfreq_mask_processed=False\ntpwra=-99\ntpwrb=-99\nfirst_time = 0\npacet = time.time()\ncorr_sin = 1.0e-12\ncorr_cos = 1.0e-12\ndpwr=0.0\napwr=0.0\nimport copy\n\ndef do_annotation(ra,dec,baseline,annotation,bw,abw,freq,srate,prefix):\n    ltp = time.gmtime()\n    if len(annotation) <= 0:\n        return True\n    fn = \"%s%04d%02d%02d-annotation.txt\" % (prefix, ltp.tm_year, ltp.tm_mon, ltp.tm_mday)\n    fp = open(fn, \"a\")\n    fp.write (\"Annotation update: %04d%02d%02d-%02d:%02d:%02d\\n\" % \n        (ltp.tm_year, ltp.tm_mon, ltp.tm_mday, ltp.tm_hour, ltp.tm_min, ltp.tm_sec))\n    fp.write (\"RA: %6.2f\\n\" % ra)\n    fp.write (\"DEC: %6.2f\\n\" % dec)\n    fp.write (\"Baseline length: %6.2fm\\n\" % baseline)\n    fp.write (\"Annotation: %s\\n\" % annotation)\n    fp.write (\"Input Filter Bandwidth: %6.2fMHz\\n\" % (bw/1.0e6))\n    fp.write (\"Analog Bandwidth: %6.2fMHz\\n\" % (abw/1.0e6))\n    fp.write (\"Frequency: %8.4fMHz\\n\" % (freq/1.0e6))\n    fp.write (\"Sample rate: %6.2fMsps\\n\\n\" % (srate/1.0e6))\n    fp.close()\n    return True\n    \n    \ndef fft_log(p,p2,corr,frq,bw,longitude,normalize,prefix,decln,flist,again,ffa,mode,zt,decfile,tpi,spi,hz):\n    global fft_buffer\n    global first_time\n    global lastt\n    global lasttpt\n    global baseline_buffer\n    global baseline_buffer2\n    global fft2_buffer\n    global tpwra, tpwrb\n    global dpwr\n    global apwr\n    global freq_mask\n    global freq_mask_processed\n    global pacet\n    global corr_cos, corr_sin\n    global zeromap\n\n    preflist=prefix.split(\",\")\n    \n    if ((time.time() - pacet) < (1.0/hz)):\n        return False\n    \n    pacet = time.time()\n    \n    if (len(p) != len(freq_mask)):\n        fft_buffer = [1.0e-25]*len(p)\n        fft2_buffer = [0.0]*len(p)\n        baseline_buffer=[0.0]*len(p)\n        freq_mask=[1.0]*len(p)\n    \n    fplen = float(len(p))\n    if flist != \"\" and freq_mask_processed == False:\n        nmsks = 0\n        freq_mask_processed = True\n        stf = frq-(bw/2.0)\n        incr = bw/fplen\n        flist = flist.split(\",\")\n        for i in range(0,len(freq_mask)):\n            for f in flist:\n                if math.fabs(stf-float(f)) <= (incr*2.5):\n                    freq_mask[i] = 1.0e-15\n                    print(\"Setting mask at F %f position %d (%f)\" % (float(f), i, incr*float(i)))\n                    nmsks += 1\n            stf += incr\n        print(\"Total mask percentage %f\" % ((float(nmsks)/fplen)*100.0))\n                \n    if fft_buffer[10] < 1.0e-24:\n        fft_buffer = numpy.copy(p)\n\n    pwra = 0.0\n    pwrb = 0.0\n    diff = 0.0\n    a = getalpha(1.0/ffa, hz)\n\n    \n    #\n    # Use numpy to process the log10-FFT buffers and turn them\n    #  into linear values\n    #\n    ta = numpy.divide(p,[10.0]*len(p))\n    ta = numpy.power([10.0]*len(ta),ta)\n    ta = numpy.multiply(ta,freq_mask)\n    pwra = numpy.sum(ta)\n    \n    tb = numpy.divide(p2,[10.0]*len(p))\n    tb = numpy.power([10.0]*len(tb),tb)\n    tb = numpy.multiply(tb,freq_mask)\n    pwrb = numpy.sum(tb)\n    \n    ffts = [ta, tb]\n    \n    w = 0\n    for  tf in ffts:\n        #\n        # To guard against log10 blowing up\n        #\n        tf = numpy.add([1.0e-22]*len(tf), tf)\n\n        #\n        # Integrate as a vector\n        #\n        tf = numpy.multiply([a]*len(tf),tf)\n        tf2 = numpy.multiply([1.0-a]*len(tf), fft_buffer if w == 0 else fft2_buffer)\n        tf = numpy.add(tf2,tf)\n\n        #\n        # Update it BEFORE we convert to log10, dummy\n        #\n        if (w == 0):\n            fft_buffer = tf\n        else:\n            fft2_buffer = tf\n        \n        w += 1\n    \n    \n    atp=a\n    \n    #\n    # Gain settings\n    #\n    corr_a = corr.real * again\n    corr_b = corr.imag * again\n    pwra *= again\n    pwrb *= again\n    \n    #\n    # Prime the integrator\n    #\n    if (tpwra < -10):\n        tpwra = pwra\n        tpwrb = pwrb\n        \n    if (corr_cos < -1.0e-10):\n        corr_cos = corr_a\n        corr_sin = corr_b\n    \n    #\n    # Integration\n    #\n    corr_cos = (atp * corr_a) + ((1.0 - atp)*corr_cos)\n    corr_sin = (atp * corr_b) + ((1.0 - atp)*corr_sin)\n\n    tpwra = (atp * pwra) + ((1.0 - atp)*tpwra)\n    tpwrb = (atp * pwrb) + ((1.0 - atp)*tpwrb)\n    \n    \n    diff = tpwra - tpwrb\n    added = tpwra + tpwrb\n\n    if (first_time == 0):\n        first_time = int(time.time())\n    \n    if (mode == \"differential\" or mode == \"diff\"):\n        dpwr = diff\n        apwr = added\n    \n    elif (mode == \"interferometer\" or mode == \"corr\" or mode == \"correlator\"):\n        dpwr = corr_cos\n        apwr = corr_sin\n    \n    else:\n        dpwr = tpwra   \n        apwr = 0.0\n\n    #\n    # Allow integrators to settle, etc, so don't write \"ramp up\" data\n    #\n    if ((time.time() - first_time) > 20):\n            \n        if (time.time() - lasttpt) >= tpi:\n            lasttpt = time.time()\n            \n            ltp = time.gmtime()\n            for prefix in preflist:\n                fn=\"%s%04d%02d%02d-tp.csv\" % (prefix, ltp.tm_year, ltp.tm_mon, ltp.tm_mday)\n                f = open (fn, \"a\")\n                f.write (\"%02d,%02d,%02d,\" % (ltp.tm_hour, ltp.tm_min, ltp.tm_sec))\n                f.write (\"%s,\" % cur_sidereal(longitude))\n                f.write(\"%5.5f,\" % (frq/1.0e6))\n                f.write(\"%5.5f,\" % bw)\n                f.write(\"%5.1f,\" % decln)\n                f.write(\"%10.7f,\" % tpwra)\n                f.write(\"%10.7f,\" % tpwrb)\n                f.write(\"%10.7f,\" % diff)\n                f.write(\"%10.7f,\" % added)\n                f.write(\"%10.7f,%10.7f\\n\" %  (corr_cos, corr_sin))\n                f.close()\n        \n        if (time.time() - lastt) >= spi:\n            lastt = time.time()\n            ltp = time.gmtime()\n            \n            ffts = [fft_buffer, fft2_buffer]\n            for w in [0,1]:\n                for prefix in preflist:\n                    fn = \"%s%04d%02d%02d-%d-spec.csv\" % (prefix, ltp.tm_year, ltp.tm_mon, ltp.tm_mday, w)\n                    f = open (fn, \"a\")\n                    f.write (\"%02d,%02d,%02d,\" % (ltp.tm_hour, ltp.tm_min, ltp.tm_sec))\n                    f.write (\"%s,\" % cur_sidereal(longitude))\n                    f.write(\"%5.5f,\" % (frq/1.0e6))\n                    f.write(\"%5.5f,\" % bw)\n                    f.write(\"%5.1f,\" % decln)\n                    \n                    st = cur_sidereal(longitude)\n                    st = st.split(\",\")\n                    st_h = float(st[0])\n                    st_h += float(st[1])/60.0\n                    st_h += float(st[2])/3600.0\n                        \n                    for i in range(0,len(ffts[w])):\n                        try:\n                            f.write(\"%6.2f,\" % (math.log10(ffts[w][i])*10.0))\n                        except:\n                            f.write(\"???,\")\n                    f.write (\"\\n\")\n                    f.close()\n                    \n                    d_ndx = int(decln)\n                    if (d_ndx in zeromap and (st_h - zeromap[d_ndx]) < (35.0/3600.0)):\n                        baseline_setter(1)\n            return 1\n        \n    return 0\n \ndef smooth(vect,a=0.4):\n    return vect\n    ovect=[0]*len(vect)\n    val=vect[0]\n    for i in range(0,len(vect)):\n        val = (a*vect[i]) + ((1.0 - a)*val)\n        ovect[i] = val\n    \n    return ovect   \n    \ndef avgvect(v1, v2):\n    q = map(operator.add, v1, v2)\n    return map(operator.div, q, [2]*len(v1))\n\ndef cur_sidereal(longitude):\n    longstr = \"%02d\" % int(longitude)\n    longstr = longstr + \":\"\n    longitude = abs(longitude)\n    frac = longitude - int(longitude)\n    frac *= 60\n    mins = int(frac)\n    longstr += \"%02d\" % mins\n    longstr += \":00\"\n    x = ephem.Observer()\n    x.date = ephem.now()\n    x.long = longstr\n    jdate = ephem.julian_date(x)\n    tokens=str(x.sidereal_time()).split(\":\")\n    hours=int(tokens[0])\n    minutes=int(tokens[1])\n    seconds=int(float(tokens[2]))\n    sidt = \"%02d,%02d,%02d\" % (hours, minutes, seconds)\n    return (sidt)\n    \ndef curr_findx(pace):\n    global  sched_index\n    global schedule\n    global baseline_count\n    global MAX_BASELINE\n    \n    if baseline_count > MAX_BASELINE:\n        return 0\n\n    cur=schedule[sched_index]\n    sched_index = sched_index + 1\n    if sched_index >= len(schedule):\n        sched_index = 0\n    return cur\n\n\n#\n# Get (baselined) FFT buffer, whichever is selected for display\n#\ndef curr_diff(pace,normalize,expected,which):\n    global fft_buffer\n    global baseline_buffer\n    global fft2_buffer\n    global baseline_buffer2\n    \n    inbuf = [fft_buffer, fft2_buffer]\n    basebuf = [baseline_buffer, baseline_buffer2]\n    \n    if (len(fft_buffer) != expected):\n        return ([-120.0]*expected)\n    \n    if (numpy.sum(basebuf[which]) == 0.0):\n        x = inbuf[which]\n    else:\n        y = map(operator.add, basebuf[which], [1.0e-24]*len(basebuf[which]))\n        x = map(operator.truediv, inbuf[which], smooth(y,a=0.5))\n    x = numpy.add(x, [1.0e-24]*len(x))\n    x = numpy.abs(x)\n    return numpy.multiply(numpy.log10(x),[10.0]*len(x))\n    \ndef not_the_norm(vect):\n    m=min(vect)\n    s=[m]*len(vect)\n    return map(operator.sub, vect, s)\n\ndef baseline_setter(thing):\n    global baseline_buffer\n    global baseline_buffer2\n    global fft_buffer\n    global fft_buffer2\n    \n    if thing != 0:\n        baseline_buffer = smooth(fft_buffer,a=0.5)\n        baseline_buffer = numpy.multiply(baseline_buffer,[0.95]*len(baseline_buffer))\n        baseline_buffer2 = smooth(fft2_buffer,a=0.5)\n        baseline_buffer2 = numpy.multiply(baseline_buffer2, [0.95]*len(baseline_buffer2))\n\ndef baseline_clearer(thing):\n    global baseline_buffer\n    global fft_buffer\n    global baseline_buffer2\n    global fft2_buffer\n    \n    if thing != 0:\n        baseline_buffer = [0.0]*len(fft_buffer)\n        baseline_buffer2 = [0.0]*len(fft2_buffer)\n\ndef lmst_string(pacer,longitude):\n    return cur_sidereal(longitude).replace(\",\", \":\")\n\n\nTPLEN=3600\ntp_vect=[0.0]*TPLEN\ntp_vect2=[0.0]*TPLEN\ndef get_tp_vect(pacer):\n    global tp_vect\n    global tp_vect2\n    global dpwr\n    global apwr\n    global TPLEN\n    \n    \n    tp_vect=tp_vect[0:(TPLEN-1)]\n    tp_vect=[dpwr]+tp_vect\n    \n    tp_vect2=tp_vect2[0:(TPLEN-1)]\n    tp_vect2=[apwr]+tp_vect2\n    \n    if len(tp_vect) != TPLEN:\n        print(\"Blarf!!! short TP_VECT\")\n    \n    return ([tp_vect,tp_vect2])\n            \n\ntpwr = 0 \ndef lmst_hours(pacer,longitude):\n    x = lmst_string(1,longitude)\n    \n    x = x.split(\":\")\n    hours = float(x[0])\n    hours += float(x[1])/60.0\n    hours += float(x[2])/3600.0\n    \n    return hours\n\n#\n#\n# Calculations for automated fringe-stopping\n#\n# We are called on a regular basis to produce a complex rotation value that is\n#  applied to one leg of the interferometer, to reduce the fringe frequency to\n#  close-to zero, thus allowing longer integration times.\n#\ndef ha (ra,longit):\n    #\n    # First get current sidereal time as as HH:MM:SS string\n    #\n    lmst = cur_sidereal (longit)\n    parts = lmst.split(\",\")\n    \n    #\n    # Re-express lmst (string) as a decimal hours\n    #\n    lmst = float(parts[0])\n    lmst += float(parts[1]) / 60.0\n    lmst += float(parts[2]) / 3600.0\n    \n    #\n    # Now compute relative hour-angle between us, and the object in question (at some RA)\n    #   When we're done, we have the relative hour-angle in radians\n    #\n    h = ra - lmst\n    return (h)\n#\n# Phase accumulator\n#\nphase_accum = 0.0\n\n#\n# For time-delta calcs\n#\nlast_time_phase = -99.0\n\n#\n# Earth rotation in radians/second\n#\nearth = math.radians(360.0 / 86400.0)\n\n#\n# Since part of the calculation only needs to be done when baseline or\n#  frequency changes, we keep 'em global\ngbaseline = 0.0\ngfreq = 0.0\nbasefreqrot = 0.0\n\n#\n# Another part only changes when dec/latit changes\n#\ngdec = -99.0\nglatit = -99.0\ndeclatrot = 0.0\n\n#\n# The combination of the two\n#\nbaserot = 0.0\n\n#\n# Speed of light, in case it wasn't obvious :)\n#\nC = 299792000.0\n\n#\n#\n# Compute phase-rotation value based either on manual input, or automatic\n#   fringe rotation\n#\n# pacer   - ignored, simply used as a \"dummy\" variable in the flow-graph to\n#           make sure that we're called regularly.\n# ra       - The RA in fractional hours\n# dec      - The DEC in fractional degrees\n# longit   - Our geographic longitude\n# latit    - Our geographic latitude\n# baseline - Baseline length, in meters\n# ena      - Whether automagic or manual is in use\n# manval   - The manual value\n# freq     - The sky frequency\n#\n#\n# These calculations assume a meridian-transit type setup, with a strictly east-west baseline\n#\ndef fringe_stop (pacer, ra, dec, longit, latit, baseline, ena, manval, freq):\n    global phase_accum\n    global last_time_phase\n    global earth\n    global gbaseline\n    global gfreq\n    global basefreqrot\n    global declatrot\n    global gdec\n    global glatit\n    global baserot\n \n    #\n    # Just compute the fixed-value from the degrees input by the UI\n    #\n    if ena == False:\n        radians = math.radians(manval)\n        return (complex(math.cos(radians),math.sin(radians)))\n\n   \n    #\n    # Handle initialization of our time-delta calculator\n    #\n    if last_time_phase < 0:\n        last_time_phase = time.time()\n\n    #\n    # Compute time delta compared to last-time\n    #\n    now = time.time()\n    tdelt = now - last_time_phase\n    \n    #\n    # Remember \"now\" for next time\n    #\n    last_time_phase = now\n    \n    changed = False\n    \n    #\n    # If baseline or freq parameters have changed\n    #\n    if baseline != gbaseline or freq != gfreq:\n        gbaseline = baseline\n        gfreq = freq\n        basefreqrot = (baseline * earth)/(C / freq)\n        changed = True\n    \n    #\n    # If dec or latit changes\n    #\n    if dec != gdec or latit != glatit:\n        gdec = dec\n        glatit = latit\n        declatrot = math.cos(math.radians(dec))*math.cos(math.radians(latit))\n        changed = True\n    \n    #\n    # Update the combined \"baserot\"\n    #\n    if changed == True:\n        baserot = basefreqrot * declatrot\n        \n    #\n    # First get current sidereal time as as HH:MM:SS string\n    #\n    lmst = cur_sidereal (longit)\n    parts = lmst.split(\",\")\n    \n    #\n    # Re-express lmst (string) as a decimal hours\n    #\n    lmst = float(parts[0])\n    lmst += float(parts[1]) / 60.0\n    lmst += float(parts[2]) / 3600.0\n    \n    #\n    # Now compute relative hour-angle between us, and the object in question (at some RA)\n    #   When we're done, we have the relative hour-angle in radians\n    #\n    h = ra - lmst\n    h *= math.radians((360.0 / 24.0))\n        \n    #\n    # Compute fringe rate in radians/hour\n    #\n    # h       - relative hour-angle, in radians between us and source\n    #\n    # Other parameters to the equation don't change with time, so they're\n    #   efficiently pre-computed above, and re-computed when the input\n    #   parameters change\n    #\n    F = baserot*math.sin(h)\n    \n    #\n    # Because I get lost in the units, the above may be in radians/hour\n    #   or radians/second so we can just adjust this scaling for the calculation below\n    #\n    scale = 1.0/3600.0\n    \n    #\n    # Update the phase accumulator (stored in radians)\n    # Handle phase-wrap gracefully\n    # (although, the Python transcendentals handle this just fine themselves)\n    #\n    phase_accum += tdelt*(F * scale)\n    if phase_accum > 2.0*math.pi:\n        phase_accum -= (2.0*math.pi)\n    \n    #\n    # We return a value that can be used by the phase rotator in the flow-graph\n    #\n    rval = complex(math.cos(phase_accum),math.sin(phase_accum))\n    return (rval)\n\ndef doppler_start(ifreq, dfreq, bw):\n    if (dfreq == 0.0):\n        stf = ifreq - bw/2.0\n        dop = (ifreq - stf) / ifreq\n        dop *= 299792.0\n    else:\n        stf = ifreq - bw/2.0\n        dop = (dfreq - stf) / dfreq\n        dop *= 299792.0\n    return dop\n\nui_decln = [time.time(), None]\nf_decln = [time.time(), None]\ndef get_decln(decln,decfile,dummy):\n    global ui_decln\n    global f_decln\n    try:\n        newdec = open(decfile,\"r\").readline().strip(\"\\n\")\n        newdec = float(newdec)\n        if (newdec != f_decln[1]):\n            f_decln = [time.time(), newdec]\n    except:\n        pass\n    \n    if (decln != ui_decln[1]):\n        ui_decln = [time.time(), decln]\n\n    if (f_decln[0] > ui_decln[0]):\n        return(f_decln[1])\n    else:\n        return(ui_decln[1])\n \ndef plotlabel(mode, which):\n    w1 = {\"total\" : \"TP\", \"tp\" : \"TP\", \"diff\" : \"Diff\", \"differential\" : \"Diff\", \"interf\" : \"Cos\", \"interferometer\" : \"Cos\",\n        \"correlator\" : \"Cos\"}\n    w2 = {\"total\" : \"Zero\", \"tp\" : \"Zero\", \"diff\" : \"Sum\", \"differential\" : \"Sum\", \"interf\" : \"Sin\", \"interferometer\" : \"Sin\",\n        \"correlator\" : \"Sin\"}\n    \n    ary = [w1,w2]\n    \n    di = ary[which]\n    return (di[mode])\n\ndef get_spec_labels(mode):\n    w1 = {\"total\" : \"SKY\", \"tp\" : \"SKY\", \"diff\" : \"SKY\", \"differential\" : \"SKY\", \"interf\" : \"East\", \"interferometer\" : \"East\",\n        \"correlator\" : \"East\"}\n    w2 = {\"total\" : \"Zero\", \"tp\" : \"Zero\", \"diff\" : \"REF\", \"differential\" : \"REF\", \"interf\" : \"West\", \"interferometer\" : \"West\",\n        \"correlator\" : \"West\"}\n    \n    return ([w1[mode],w2[mode]])\n    \ndef init_zero_map(zf):\n    global zeromap\n    cnt = 0\n    \n    if (\"\" != zf and zf != None):\n        try:\n            f = open(zf, \"r\")\n            lines = f.readlines()\n            f.close()\n            for l in lines:\n                l = l.replace(\"\\n\", \"\")\n                ts = l.split(\" \")\n                zeromap[int(ts[0])] = float(ts[1])\n                cnt += 1\n        except:\n            pass\n    return cnt\n            \n"
  states: {}
- name: srate
  id: parameter
  parameters:
    label: Sample rate
    type: eng_float
    value: 2.50e6
  states: {}
- name: tp_interval
  id: parameter
  parameters:
    label: TP Logging Interval
    type: intx
    value: '2'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: fft_decim_vectors
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: fft_filtered
  states: {}
- name: virtual_sink_1_0
  id: virtual_sink
  parameters:
    stream_id: fft2_filtered
  states: {}
- name: virtual_sink_2
  id: virtual_sink
  parameters:
    stream_id: Chan0
  states: {}
- name: virtual_sink_2_0
  id: virtual_sink
  parameters:
    stream_id: Chan1
  states: {}
- name: virtual_sink_3
  id: virtual_sink
  parameters:
    stream_id: pfb0
  states: {}
- name: virtual_sink_4
  id: virtual_sink
  parameters:
    stream_id: pfb_out0
  states: {}
- name: virtual_sink_4_0
  id: virtual_sink
  parameters:
    stream_id: pfb_out1
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: fft_decim_vectors
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: fft_filtered
  states: {}
- name: virtual_source_1_0
  id: virtual_source
  parameters:
    stream_id: fft2_filtered
  states: {}
- name: virtual_source_2
  id: virtual_source
  parameters:
    stream_id: Chan0
  states: {}
- name: virtual_source_2_0
  id: virtual_source
  parameters:
    stream_id: Chan1
  states: {}
- name: virtual_source_3
  id: virtual_source
  parameters:
    stream_id: Chan0
  states: {}
- name: virtual_source_3_0
  id: virtual_source
  parameters:
    stream_id: Chan1
  states: {}
- name: virtual_source_4
  id: virtual_source
  parameters:
    stream_id: Chan0
  states: {}
- name: virtual_source_4_0
  id: virtual_source
  parameters:
    stream_id: Chan1
  states: {}
- name: virtual_source_5
  id: virtual_source
  parameters:
    stream_id: pfb0
  states: {}
- name: virtual_source_5_0
  id: virtual_source
  parameters:
    stream_id: pfb1
  states: {}
- name: virtual_source_6
  id: virtual_source
  parameters:
    stream_id: pfb_out0
  states: {}
- name: virtual_source_6_0
  id: virtual_source
  parameters:
    stream_id: pfb_out1
  states: {}
- name: zerofile
  id: parameter
  parameters:
    label: File containing zeroing map
    value: '""'
  states: {}
- name: zerotime
  id: parameter
  parameters:
    label: SIdereal time for auto baseline set
    type: eng_float
    value: '99.3'
  states: {}

connections:
- [blocks_add_const_vxx_0, '0', qtgui_vector_sink_f_0, '0']
- [blocks_add_const_vxx_0, '0', qtgui_vector_sink_f_0_1, '0']
- [blocks_add_const_vxx_0_0, '0', qtgui_vector_sink_f_0_0, '0']
- [blocks_add_const_vxx_0_0_0, '0', qtgui_vector_sink_f_0_0, '1']
- [blocks_add_const_vxx_0_1, '0', qtgui_vector_sink_f_0, '1']
- [blocks_add_const_vxx_0_1, '0', qtgui_vector_sink_f_0_1, '1']
- [blocks_add_const_vxx_1, '0', blocks_stream_to_vector_0_0, '0']
- [blocks_add_xx_0, '0', qtgui_waterfall_sink_x_0, '0']
- [blocks_add_xx_1, '0', virtual_sink_4, '0']
- [blocks_add_xx_1_0, '0', virtual_sink_4_0, '0']
- [blocks_complex_to_mag_squared_0, '0', single_pole_iir_filter_xx_0, '0']
- [blocks_complex_to_mag_squared_0_0, '0', single_pole_iir_filter_xx_0_0, '0']
- [blocks_delay_0, '0', blocks_multiply_const_vxx_4, '0']
- [blocks_delay_0_1, '0', blocks_multiply_const_vxx_4_2, '0']
- [blocks_keep_m_in_n_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_keep_m_in_n_0_0, '0', blocks_add_const_vxx_1, '0']
- [blocks_keep_one_in_n_0, '0', blocks_nlog10_ff_0, '0']
- [blocks_keep_one_in_n_0_0, '0', blocks_nlog10_ff_0_0, '0']
- [blocks_keep_one_in_n_1, '0', blocks_sub_xx_0, '0']
- [blocks_keep_one_in_n_1, '0', single_pole_iir_filter_xx_2, '0']
- [blocks_multiply_conjugate_cc_0, '0', single_pole_iir_filter_xx_1, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_multiply_conjugate_cc_0, '0']
- [blocks_multiply_const_vxx_1, '0', blocks_add_const_vxx_0, '0']
- [blocks_multiply_const_vxx_1, '0', blocks_add_const_vxx_0_1, '0']
- [blocks_multiply_const_vxx_2, '0', blocks_sub_xx_0, '1']
- [blocks_multiply_const_vxx_3, '0', blocks_add_xx_0, '0']
- [blocks_multiply_const_vxx_3_0, '0', blocks_add_xx_0, '1']
- [blocks_multiply_const_vxx_4, '0', blocks_add_xx_1, '1']
- [blocks_multiply_const_vxx_4_0, '0', blocks_add_xx_1, '0']
- [blocks_multiply_const_vxx_4_0_0, '0', blocks_add_xx_1_0, '0']
- [blocks_multiply_const_vxx_4_2, '0', blocks_add_xx_1_0, '1']
- [blocks_nlog10_ff_0, '0', fft_probe, '0']
- [blocks_nlog10_ff_0, '0', virtual_sink_0, '0']
- [blocks_nlog10_ff_0_0, '0', fft2_probe, '0']
- [blocks_null_source_0, '0', blocks_add_const_vxx_0_0, '0']
- [blocks_null_source_0, '0', blocks_add_const_vxx_0_0_0, '0']
- [blocks_stream_to_vector_0, '0', virtual_sink_3, '0']
- [blocks_stream_to_vector_0_0, '0', cronk, '0']
- [blocks_sub_xx_0, '0', corr_probe, '0']
- [fft_vxx_0, '0', blocks_complex_to_mag_squared_0, '0']
- [fft_vxx_0_0, '0', blocks_complex_to_mag_squared_0_0, '0']
- [osmosdr_source_0, '0', virtual_sink_2, '0']
- [osmosdr_source_0, '1', virtual_sink_2_0, '0']
- [single_pole_iir_filter_xx_0, '0', virtual_sink_1, '0']
- [single_pole_iir_filter_xx_0_0, '0', virtual_sink_1_0, '0']
- [single_pole_iir_filter_xx_1, '0', blocks_keep_one_in_n_1, '0']
- [single_pole_iir_filter_xx_2, '0', blocks_multiply_const_vxx_2, '0']
- [virtual_source_0, '0', blocks_multiply_const_vxx_1, '0']
- [virtual_source_1, '0', blocks_keep_one_in_n_0, '0']
- [virtual_source_1_0, '0', blocks_keep_one_in_n_0_0, '0']
- [virtual_source_2, '0', blocks_keep_m_in_n_0, '0']
- [virtual_source_2_0, '0', blocks_keep_m_in_n_0_0, '0']
- [virtual_source_3, '0', blocks_multiply_const_vxx_0, '0']
- [virtual_source_3_0, '0', blocks_multiply_conjugate_cc_0, '1']
- [virtual_source_4, '0', blocks_multiply_const_vxx_3, '0']
- [virtual_source_4_0, '0', blocks_multiply_const_vxx_3_0, '0']
- [virtual_source_5, '0', blocks_delay_0, '0']
- [virtual_source_5, '0', blocks_multiply_const_vxx_4_0, '0']
- [virtual_source_5_0, '0', blocks_delay_0_1, '0']
- [virtual_source_5_0, '0', blocks_multiply_const_vxx_4_0_0, '0']
- [virtual_source_6, '0', fft_vxx_0, '0']
- [virtual_source_6_0, '0', fft_vxx_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
